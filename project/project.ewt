<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM8L15X_HD(STM8L15xx8_16xx8)</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <group>
    <name>OS</name>
    <file>
      <name>$PROJ_DIR$\os\app_scheduler.c</name>
    </file>
  </group>
  <group>
    <name>STM8L15x_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_irtim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_tim3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_tim5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_wfe.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\src\stm8l15x_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>Usr</name>
    <file>
      <name>$PROJ_DIR$\usr\src\app_trace.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\usr\src\count.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\usr\src\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\usr\inc\includes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\usr\src\key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\usr\src\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\usr\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\usr\src\stm8l15x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\usr\src\valve.c</name>
    </file>
  </group>
</project>


