<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM8L15X_HD(STM8L15xx8_16xx8)</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <group>
    <name>driver</name>
    <file>
      <name>$PROJ_DIR$\..\Source\driver\src\at88sc102.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\driver\src\sle4442.c</name>
    </file>
  </group>
  <group>
    <name>OS</name>
    <file>
      <name>$PROJ_DIR$\..\Source\os\app_scheduler.c</name>
    </file>
  </group>
  <group>
    <name>STM8L15x_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_irtim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_tim3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_tim5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_wfe.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\lib\src\stm8l15x_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>Usr</name>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\app_trace.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\battery.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\beeper.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\cc1120_rx_sniff_mode_rx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\cc112x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\cc112x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\count.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\dataConvert.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\hal_spi_rf_trxeb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\ic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\lcd_sc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\pvd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\stm8l15x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\usr\src\valve.c</name>
    </file>
  </group>
</project>


